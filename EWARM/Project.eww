<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32f103vct6_source.ewp</path>
  </project>
  <batchBuild />
</workspace>
