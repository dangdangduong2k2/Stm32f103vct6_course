# IAR project stm32f103vct6_source.ewp, settings and files
configuration stm32f103vct6_source (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VC ST STM32F103VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32f103vct6_source.hex
  ILINK.IlinkOutputFile: stm32f103vct6_source.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c
  group Application/User/Core/clock
    ../Core/Src/: clock.c
    ../Core/Inc/: clock.h
  group Application/User/Core/gpio
    ../Core/Src/: gpio.c
    ../Core/Inc/: gpio.h
  group Application/User/Core/IC_74AC165D
    ../Core/Src/: IC_74AC165D.c
    ../Core/Inc/: IC_74AC165D.h
  group Application/User/Core/IC_74HC594
    ../Core/Src/: IC_74HC594.c
    ../Core/Inc/: IC_74HC594.h
  group Application/User/Core/LCD
    C:/Users/84921/Documents/Zalo Received Files/: LCD_Lib.c LCD_Lib.h
  group Application/User/Core/timer
    ../Core/Src/: timer.c
    ../Core/Inc/: timer.h
  group Application/User/Core/uart
    ../Core/Src/: uart.c
    ../Core/Inc/: uart.h
  group Drivers
    ../Core/Src/: stm32f1xx_hal_msp.c stm32f1xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
